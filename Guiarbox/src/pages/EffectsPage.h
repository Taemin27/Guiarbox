#pragma once
#include "Page.h"
#include "../config/Colors.h"
#include "../config/Effects/EffectsRegistry.h"
#include "../menuItems/MenuItem.h"
#include "../menuItems/IntEditor.h"
#include "../menuItems/FloatEditor.h"
#include "../menuItems/OptionsSelector.h"
#include "../menuItems/ToggleButton.h"
#include "../menuItems/SimpleButton.h"
#include "../menuItems/ScrollableMenuView.h"
#include <vector>

#include "../config/Effects/PresetManager.h"
#include "../config/SystemBitmaps.h"
#include "../config/Display.h"

extern GFXBuffer_t display;
extern Bounce bounce;
extern void drawArrows();
extern int readEncoder();

const unsigned char EFFECTS_HOME_BITMAP [] = {
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xf8, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x1f, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x7f, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0xfc, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x1f, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x7f, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xff, 0xf8, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xff, 0xc0, 0x7c, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1f, 
	0xff, 0x00, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x3f, 0xfc, 0x00, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3f, 0xf0, 0x00, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3f, 0xc0, 0x00, 0x7c, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 
	0x00, 0x00, 0x7c, 0x3f, 0xff, 0x81, 0xf1, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x3f, 0xff, 0x83, 0xf3, 0xf0, 0x00, 0x00, 0x00, 0x06, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x3f, 0xff, 0x87, 0x87, 0x80, 
	0x00, 0x00, 0x00, 0x0e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 
	0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 
	0x00, 0x00, 0x7c, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0e, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0e, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 0x00, 0x1f, 0xdf, 0xc0, 
	0xfc, 0x00, 0xfc, 0x3f, 0x83, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 
	0x00, 0x1f, 0xdf, 0xc1, 0xff, 0x03, 0xfe, 0x3f, 0x8f, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 
	0x00, 0x00, 0x7c, 0x3f, 0xff, 0x07, 0x07, 0x03, 0x87, 0x87, 0x87, 0x0e, 0x1e, 0x1e, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x3f, 0xff, 0x07, 0x07, 0x07, 0x03, 0x87, 0x07, 0x8e, 
	0x1c, 0x0e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x3f, 0xff, 0x07, 0x07, 0x0e, 
	0x01, 0xce, 0x03, 0x8e, 0x1c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 
	0x00, 0x07, 0x07, 0x0e, 0x01, 0xce, 0x00, 0x0e, 0x1f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 
	0x00, 0x00, 0x7c, 0x38, 0x00, 0x07, 0x07, 0x0f, 0xff, 0xce, 0x00, 0x0e, 0x0f, 0xe0, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 0x00, 0x07, 0x07, 0x0f, 0xff, 0xce, 0x00, 0x0e, 
	0x03, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 0x00, 0x07, 0x07, 0x0e, 
	0x00, 0x0e, 0x00, 0x0e, 0x00, 0x7e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 
	0x00, 0x07, 0x07, 0x0e, 0x00, 0x0e, 0x03, 0x8e, 0x00, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 
	0x00, 0x00, 0x7c, 0x38, 0x00, 0x07, 0x07, 0x0f, 0x01, 0xce, 0x03, 0x8e, 0x1c, 0x07, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x38, 0x00, 0x07, 0x07, 0x07, 0x03, 0x87, 0x07, 0x0e, 
	0x1e, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x3f, 0xff, 0x87, 0x07, 0x07, 
	0x87, 0x87, 0x8f, 0x0e, 0x0f, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x00, 0x7c, 0x3f, 
	0xff, 0x87, 0x07, 0x03, 0xff, 0x03, 0xfe, 0x0f, 0x87, 0xfe, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 
	0x00, 0x07, 0xfc, 0x3f, 0xff, 0x87, 0x07, 0x00, 0xfc, 0x00, 0xf8, 0x07, 0x83, 0xf8, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x3e, 0x00, 0x1f, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x7f, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xfe, 0x00, 0xff, 0xfc, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xfe, 
	0x00, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x3f, 0xfe, 0x01, 0xff, 0xfc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7f, 0xfe, 0x01, 0xff, 0xf8, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7f, 0xfe, 0x01, 0xff, 0xf8, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xfe, 
	0x00, 0xff, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0xff, 0xfc, 0x00, 0xff, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xfc, 0x00, 0x7f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7f, 0xf8, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7f, 0xe0, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x3f, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

class EffectsPage : public Page {
private:
    static constexpr int16_t ROW_HEIGHT_PX = 16;
    static constexpr int16_t SCREEN_W = 160;
    static constexpr int16_t SCREEN_H = 80;

    static constexpr int CATEGORY_ITEM_COUNT = 4;
    static constexpr int EFFECT_ITEM_COUNT = 2;
    static constexpr int PARAMETER_ITEM_COUNT = 3;

	enum View { CATEGORY, EFFECT, PARAMETER };
    View currentView = CATEGORY;

    int preset = 0;
    bool presetDirty = false;
    int categoryIndex = 0;
    int categoryCursor = 0;
    int effectCursor = 0;
    int parameterCursor = 0;
    int parameterViewEffectIndex = 0;

	MenuItem* categoryViewItems[CATEGORY_ITEM_COUNT];

	struct CategoryEffects {
		const char* categoryName;
		MenuItem* effectViewItems[EFFECT_ITEM_COUNT];
	};

	std::vector<CategoryEffects> categoryEffects;

	struct EffectParameters {
		EffectManager* manager;
		MenuItem* parameterViewItems[PARAMETER_ITEM_COUNT];
	};

	std::vector<EffectParameters> effectParameters;

    void drawCategoryView() {
        for (int i = 0; i < CATEGORY_ITEM_COUNT; i++) {
            categoryViewItems[i]->draw();
        }

        if (presetDirty) {
            display.setTextSize(1);
            display.setTextColor(WHITE, BLACK);
            display.setCursor(126, 0);
            display.print("*");
        }
    }

    void drawEffectView() {
        CategoryEffects& categoryEffect = categoryEffects[(size_t)categoryIndex];
        for (int i = 0; i < EFFECT_ITEM_COUNT; i++) {
            categoryEffect.effectViewItems[i]->draw();
        }
		display.setTextSize(2);
        display.setTextWrap(false);
        display.setTextColor(WHITE, BLACK);
        display.setCursor(18, 0);
        display.print(categoryEffect.categoryName);
    }

    void drawParameterView() {
        EffectParameters& effectParameter = effectParameters[(size_t)parameterViewEffectIndex];
        for (int i = 0; i < PARAMETER_ITEM_COUNT; i++) {
            effectParameter.parameterViewItems[i]->draw();
        }
    }

    void draw() {
        display.fillScreen(BLACK);
        switch (currentView) {
            case CATEGORY:
                drawCategoryView();
                break;
            case EFFECT:
                drawEffectView();
                break;
            case PARAMETER:
                drawParameterView();
                break;
        }
        flushDisplay();
    }

    void applyPresetChange() {
        PresetManager::loadPreset(preset);
        presetDirty = false;
    }

	// Generates the appropriate editor for the parameter
    MenuItem* paramToEditor(const EffectParameter& param, int16_t px, int16_t py, int16_t w, uint8_t textSize, Align align) {
        switch (param.type) {
            case ParamType::Float:
                return new FloatEditor(px, py, w, param.name,
                                       (float*)param.valuePtr, param.step, param.decimals,
                                       param.minValue, param.maxValue, textSize, align);
            case ParamType::Int:
                return new IntEditor(px, py, w, param.name,
                                     (int*)param.valuePtr, (int)param.step,
                                     (int)param.minValue, (int)param.maxValue, textSize, align);
            case ParamType::Bool:
                return new ToggleButton(px, py, w, param.name, (bool*)param.valuePtr, textSize, align);
            case ParamType::Option:
                return new OptionsSelector(px, py, w, param.name,
                                           param.options, param.optionCount,
                                           (int*)param.valuePtr, textSize, align);
            default:
                return nullptr;
        }
    }

public:

    EffectsPage() {
		int numCategories = sizeof(effectsRegistry) / sizeof(effectsRegistry[0]);

		// ========== Category view items ==========
		categoryViewItems[0] = new SimpleButton(0, 0, 0, "<", [this]() { home(); }, 2, Align::Left);
        categoryViewItems[1] = new IntEditor(18, 0, 108, "Preset:", &preset, 1, 0, 99, 2, Align::Spread);
		categoryViewItems[2] = new SimpleButton(144, 0, 16, SAVE, 16, 16, [this]() {
            PresetManager::savePreset(preset);
            presetDirty = false;
        }, Align::Right);

		// Scrollable menu view of buttons for each category
		std::vector<std::vector<MenuItem*>> group;
		std::vector<MenuItem*> page;

		for (int i = 0; i < numCategories; i++) {
			if (page.size() >= 4) {
				group.push_back(page);
				page.clear();
			}
			page.push_back(new SimpleButton(
                0, 16 * (i % 4 + 1), 160, effectsRegistry[i].name,
                [this, i]() {
                    categoryIndex = i;
                    effectCursor = 0;
                    currentView = EFFECT;
                    draw();
                },
                2, Align::Left));
		}
		if (!page.empty()) {
			group.push_back(page);
			page.clear();
		}
		categoryViewItems[3] = new ScrollableMenuView(group);
		group.clear();


		// ========== Effect view items ==========
		for (int i = 0; i < numCategories; i++) {
			CategoryEffects categoryEffect;
			categoryEffect.categoryName = effectsRegistry[i].name;
			categoryEffect.effectViewItems[0] = new SimpleButton(0, 0, 0, "<", [this]() { currentView = CATEGORY; draw(); }, 2, Align::Left);

			categoryEffect.effectViewItems[0]->setFocused(true);

			for (int j = 0; j < (int)effectsRegistry[i].effectManagers.size(); j++) {
				if (page.size() >= 4) {
					group.push_back(page);
					page.clear();
				}
				EffectManager* mgr = effectsRegistry[i].effectManagers[j];
                int flatIndex = 0;
                for (int k = 0; k < i; k++) {
                    flatIndex += (int)effectsRegistry[k].effectManagers.size();
                }
                flatIndex += j;
				page.push_back(new SimpleButton(
                    0, 16 * (j % 4 + 1), 160, mgr->getName(),
                    [this, flatIndex]() {
                        parameterViewEffectIndex = flatIndex;
                        parameterCursor = 0;
                        currentView = PARAMETER;
                        draw();
                    },
                    2, Align::Left));
			}
			if (!page.empty()) {
				group.push_back(page);
				page.clear();
			}
			
			categoryEffect.effectViewItems[1] = new ScrollableMenuView(group);
			categoryEffects.push_back(categoryEffect);
			group.clear();
		}

		// ========== Parameter view items ==========
		for (int i = 0; i < numCategories; i++) {
			for (int j = 0; j < (int)effectsRegistry[i].effectManagers.size(); j++) {
				EffectParameters effectParameter;
				EffectManager* mgr = effectsRegistry[i].effectManagers[j];
				effectParameter.manager = mgr;
				effectParameter.parameterViewItems[0] = new SimpleButton(0, 0, 0, "<", [this]() { currentView = EFFECT; draw(); }, 2, Align::Left);
				effectParameter.parameterViewItems[1] = new ToggleButton(18, 0, 142, mgr->getName(), &mgr->enabled, 2, Align::Left);

				effectParameter.parameterViewItems[0]->setFocused(true);

				for (int k = 0; k < mgr->getParameterCount(); k++) {
					if (page.size() >= 4) {
						group.push_back(page);
						page.clear();
					}
					EffectParameter parameter = mgr->getParameters()[k];
					page.push_back(paramToEditor(parameter, 0, 16 * (k % 4 + 1), 160, 2, Align::Spread));
				}
				if (!page.empty()) {
					group.push_back(page);
					page.clear();
				}
				effectParameter.parameterViewItems[2] = new ScrollableMenuView(group);
				effectParameters.push_back(effectParameter);
				group.clear();
			}
		}
		
	}


    void setPresetIndex(int index) {
        preset = index;
        presetDirty = false;
    }

    void refresh() override {
        if (!isActive()) {
            home();
            return;
        }
        draw();
    }

    void home() override {
		setActive(false);
        display.fillScreen(BLACK);
        display.drawBitmap(0, 0, EFFECTS_HOME_BITMAP, 160, 80, WHITE);
        drawArrows();
        flushDisplay();
    }

    void setup() override {
		categoryViewItems[0]->setFocused(true);
        display.fillScreen(BLACK);
        draw();
		
    }

    void loop() override {
        if (bounce.fell()) {
            switch (currentView) {
                case CATEGORY: {
                    MenuItem* currentItem = categoryViewItems[categoryCursor];
                    if (categoryCursor == 1) {
                        const bool wasEditing = currentItem->isEditing();
                        currentItem->onButtonPress();
                        if (wasEditing && !currentItem->isEditing()) {
                            applyPresetChange();
                        }
                    } else {
                        currentItem->onButtonPress();
                    }
                    break;
                }
                case EFFECT:
                    categoryEffects[(size_t)categoryIndex].effectViewItems[effectCursor]->onButtonPress();
                    break;
                case PARAMETER: {
                    EffectParameters& ep = effectParameters[(size_t)parameterViewEffectIndex];
                    ep.parameterViewItems[parameterCursor]->onButtonPress();
                    if (parameterCursor != 0) {
                        ep.manager->syncToChain();
                        presetDirty = true;
                    }
                    break;
                }
            }
            if (isActive()) {
                draw();
            }
        }

        int encoder = readEncoder();
        if (encoder != 0) {
            switch (currentView) {
                case CATEGORY: {
                    MenuItem* currentItem = categoryViewItems[categoryCursor];
                    const int next = categoryCursor + encoder;
                    const bool consumed = currentItem->onEncoderTurn(encoder);
                    if (!consumed && next >= 0 && next < CATEGORY_ITEM_COUNT) {
                        currentItem->setFocused(false);
                        categoryCursor = next;
                        categoryViewItems[categoryCursor]->setFocused(true);
                    }
                    if (consumed && categoryCursor == 1) {
                        applyPresetChange();
                    }
                    break;
                }
                case EFFECT: {
                    CategoryEffects& categoryEffect = categoryEffects[(size_t)categoryIndex];
                    MenuItem* currentItem = categoryEffect.effectViewItems[effectCursor];
                    const int next = effectCursor + encoder;
                    if (!currentItem->onEncoderTurn(encoder) && next >= 0 && next < EFFECT_ITEM_COUNT) {
                        currentItem->setFocused(false);
                        effectCursor = next;
                        categoryEffect.effectViewItems[effectCursor]->setFocused(true);
                    }
                    break;
                }
                case PARAMETER: {
                    EffectParameters& ep = effectParameters[(size_t)parameterViewEffectIndex];
                    MenuItem* currentItem = ep.parameterViewItems[parameterCursor];
                    const int next = parameterCursor + encoder;
                    const bool consumed = currentItem->onEncoderTurn(encoder);
                    if (!consumed && next >= 0 && next < PARAMETER_ITEM_COUNT) {
                        currentItem->setFocused(false);
                        parameterCursor = next;
                        ep.parameterViewItems[parameterCursor]->setFocused(true);
                    }
                    if (consumed) {
                        ep.manager->syncToChain();
                    }
                    break;
                }
            }
            if (isActive()) {
                draw();
            }
        }
    }
};
